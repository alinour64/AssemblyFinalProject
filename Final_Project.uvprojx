# Keil uVision project Final_Project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C129XNCZAD Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group C_Programs
    ./Assembly_Final_Project_Files/C_Programs/: driver_keil.c driver_cpg.c driver.c heap.c heap_template.c
  group Thumb2_Programs
    ./Assembly_Final_Project_Files/Thumb2_Programs/: heap_template.s startup_TM4C129_midpoint.s startup_TM4C129_template.s stdlib_midpoint.s stdlib_template.s svc_template.s timer_template.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
